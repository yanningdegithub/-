# Keil uVision project IotSmartHome.uvprojx, settings and files
target SmartHome (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IotSmartHome
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\devices\inc;..\hardware\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group boot
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group cmsis
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group devices
    ../devices/src/: basePeripheral.c infrared.c methane.c smoke.c fire.c
  group hardware
    ../hardware/src/: briupDelay.c briupUsart.c briupUsart3.c briupZigbee.c briupGPIO.c briupTim.c
  group libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group user
    ../user/: main.c protocol.c
